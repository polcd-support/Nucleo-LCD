# Keil uVision project stm32f410rb-arduino-lcd-P035M075-IPS-CTP.uvprojx, settings and files
target stm32f410rb-arduino-lcd-P035M075-IPS-CTP (6220000::V6.22::ARMCLANG)
  device: STM32F410RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f410rb-arduino-lcd-P035M075-IPS-CTP +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F410Rx
  c include: ../Core/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../src/arduino;../src/screen;../src/app
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c system_stm32f4xx.c
    ../MDK-ARM/: startup_stm32f410rx.s
  group User/src
    ../src/app/: demo_app.cpp
    ../src/screen/: screen.cpp
    ../src/screen/bus/: lcd_spi_stm32f4.cpp
    ../src/screen/panels/: panel_p035m075_ips_ctp.cpp
    ../src/screen/touch/: touch_ft6336u.cpp touch_cst816.cpp
    ../src/screen/gfx/: gfx.cpp fonts.cpp
    ../src/arduino/: Arduino.cpp SPI.cpp Wire.cpp
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
